LIBCAMERA_INC = ""
LIBCAMERA_INC:rpi = "libcamera.inc"
require ${LIBCAMERA_INC}
